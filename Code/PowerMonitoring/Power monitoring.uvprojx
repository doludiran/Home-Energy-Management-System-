# Keil uVision project Power monitoring.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Power monitoring
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: Clocks.c Clocks.h ADC_INIT.c ADC_INIT.h Power_monitoring.c Power_monitoring.h IOdef.h main.c xbee.c xbee.h serial.c serial.h systick.h systick.c
software components: CMSIS:CORE 5.1.2, Device:GPIO 1.3, Device:Startup 1.0.0
